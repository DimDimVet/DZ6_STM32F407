# Keil uVision project DZ6_STM32F407.uvprojx, settings and files
target STM32F407 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: DZ6_STM32F407
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\inc;.\app
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group app
    ./app/: app.c Task1.c RCC_F407.c GPIO_F407.c Task2.c Task3.c Task4.c Task5.c
  group inc
    ./inc/: app.h Task1.h RCC_F407.h GPIO_F407.h Task2.h Task3.h TaskSwitch.h Task4.h Task5.h
software components: CMSIS:CORE 5.6.0, Device:Startup 2.6.3
